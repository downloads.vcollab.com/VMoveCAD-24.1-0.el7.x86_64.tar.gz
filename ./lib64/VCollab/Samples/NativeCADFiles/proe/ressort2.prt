# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file ressort2.prt)

Parameters:
  PTC_COMMON_NAME = "ressort2.prt"