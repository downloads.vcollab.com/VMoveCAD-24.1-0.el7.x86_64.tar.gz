# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file cube_anno_note_mult.prt)

Parameters:
  PTC_COMMON_NAME = "prt0001.prt"